# Keil uVision project final.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: final +hex
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\STM32F1xx_HAL_Driver\Inc;.\Drivers\BSP\LED;.\Drivers\BSP\KEY;.\Drivers\BSP\EXTI;.\Drivers\BSP\MOTOR;.\Drivers\BSP\ENCODER;.\Drivers\BSP\MPU6050;.\Drivers\BSP\ADC;.\Drivers\BSP\OLED;.\SYSTEM\sys;.\SYSTEM\delay;.\SYSTEM\usart;.\HARDWARE\TIMER;.\HARDWARE\CONTROL;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Startup/: startup_stm32f103xb.s
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart/: usart.c
  group User
    ./User/: main.c stm32f1xx_it.c
  group HARDWARE
    ./HARDWARE/TIMER/: gtim.c
    ./HARDWARE/CONTROL/: control.c
  group BSP
    ./Drivers/BSP/LED/: led.c
    ./Drivers/BSP/KEY/: key.c
    ./Drivers/BSP/EXTI/: exti.c
    ./Drivers/BSP/MOTOR/: motor.c
    ./Drivers/BSP/ENCODER/: encoder.c
    ./Drivers/BSP/MPU6050/: atk_ms6050.c atk_ms6050_iic.c
    ./Drivers/BSP/ADC/: adc.c
    ./Drivers/BSP/OLED/: oled.c
  group STM32F1xx_HAL_Driver
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_exti.c
  group CMSIS
    ./Drivers/CMSIS/Device/ST/STM32F1xx/Source/: system_stm32f1xx.c
