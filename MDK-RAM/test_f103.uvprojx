# Keil uVision project test_f103.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\user;..\..\drivers;..\..\drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\drivers\CMSIS\Include;..\..\drivers\STM32F1xx_HAL_Driver\Inc;..\..\Middlewares
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../Startup/: startup_stm32f103xb.s
  group user
    ../User/: stm32f1xx_it.c main.c
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/: system_stm32f1xx.c
    ../../所需软件/5.第三方库/curveShow/: curveShow.c
    ../../所需软件/5.第三方库/OLED/: oled.c
    ../../所需软件/5.第三方库/utilities/: utilities.c
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_msp_template.c
  group drivers/system
    ../../所需软件/5.第三方库/SYSTEM-ALIENTEK/delay/: delay.c
    ../../所需软件/5.第三方库/SYSTEM-ALIENTEK/sys/: sys.c
    ../../所需软件/5.第三方库/SYSTEM-ALIENTEK/usart/: usart.c
  group drivers/stm32f4xx_hal_driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
